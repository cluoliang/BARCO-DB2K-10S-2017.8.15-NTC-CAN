# Keil uVision project Can.uvproj, settings and files
target STM32F207ZET6 (ARM-ADS)
  device: STM32F207VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: Can +hex
  c flags: Optim=1
  c define: STM32F2XX, USE_STDPERIPH_DRIVER
  c include: ..\Libraries\Core;..\Libraries\StdPeriph\inc;..\Libraries\StdPeriph\src;..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group User
    ../User/: main.c stm32f2xx_it.c led.c led.h nvic.c nvic.h systick.c systick.h uart.c uart.h i2c.c i2c.h command.c command.h adc.c adc.h exit.c tsl2581.c ds18b20.c ds18b20.h ds18b20_1.c ds18b20_1.h manage.c manage.h can.c can.h timer.c timer.h ntc.c ntc.h relay.c relay.h pwm.c pwm.h
  group Startup
    ../Libraries/Core/: startup_stm32f2xx.s
  group CMSIS
    ../Libraries/Core/: system_stm32f2xx.c
  group Stdperich
    ../Libraries/StdPeriph/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
